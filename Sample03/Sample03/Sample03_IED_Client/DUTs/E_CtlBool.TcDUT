{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_CtlBool :
(
	None:= 0,(* Idle, do nothing *)
	Disable:= 1,(* Set value to "False" *)
	Enable:= 2(* Set value to "True" *)
)SINT;
END_TYPE
